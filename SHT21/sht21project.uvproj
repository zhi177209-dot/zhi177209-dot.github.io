# Keil uVision project sht21project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: sht21project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver;.\USER;.\Oled
  group USER
    ./USER/: Main.c IIC.c SHT21.c LedDisplay.c DisplayTask.c DisplayTask.h Control.c Control.h Motor.c Motor.h Key.c Key.h Buzzer.c Buzzer.h
  group DRIVER
    ./Driver/: GPIO.c timer.c
  group OLED
    ./Oled/: oled.c
